# IAR project I2C.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: E:\STM8S\I2C_Master\Libraries\inc; E:\STM8S\I2C_Master\User
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: I2C.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Library
    ../Libraries/src/: stm8s_clk.c stm8s_gpio.c stm8s_i2c.c stm8s_tim4.c
  group User
    ../User/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
